# Keil uVision project UCB_CDC.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCB_CDC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: .\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c spi.c i2c.c usb.c usb_cdc.c
  group inc
    ./inc/: interface.h gpio.h reg.h usb_def.h usb_descriptors.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
